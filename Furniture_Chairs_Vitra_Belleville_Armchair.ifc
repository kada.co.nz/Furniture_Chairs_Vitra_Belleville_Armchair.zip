Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-01-11T13:42:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jan 11 13:42:36 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{376EF9EA-AC91-4F36-A629-6BFB7CE12800}\ifc * Database version: 5507 * Database creation date: Fri Jan 11 13:42:36 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jan 11 13:42:36 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jan 11 13:42:36 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Belleville armchair plastic, CONV_Vitra_DmstcChrs_Belleville_Armchair:Belleville armchair plastic:313135
In: Level 1
Material: Glide black, 12 deep black
Pset_ManufacturerTypeInformation - ModelReference: 44029900; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.1327 m2; Volume: 0.223685 m3
Materials and Finishes - ChairMainMaterial: 12 deep black
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: CONV_Vitra_DmstcChrs_Belleville_Armchair: Belleville armchair plastic; Family and Type: CONV_Vitra_DmstcChrs_Belleville_Armchair: Belleville armchair plastic; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: CONV_Vitra_DmstcChrs_Belleville_Armchair: Belleville armchair plastic; Type Id: CONV_Vitra_DmstcChrs_Belleville_Armchair: Belleville armchair plastic; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
General(Type) - Author: Convergo AB; BIMObjectName: CONV_Vitra_DmstcChrs_Belleville_Armchair; ConvergoRefNr: 0089-1812-0129-CH; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: The Belleville Armchair is a hybrid chair, whose seat shell is available in plastic, wood or with a cover in leather or fabric.; Revision: n/a; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Dining chairs; Uniclass2015Reference: Pr_40_50_12_22; Version: 1; VersionDate: 07/01/2019
Identity Data(Type) - Collection: Belleville; Cost: 0; Description: The Belleville Armchair is a hybrid chair, whose seat shell is available in plastic, wood or with a cover in leather or fabric. Each version lends the elegant chair a distinctive identity. The characteristic, forward curving armrests offer relaxing comfort and the model with the plastic seat shell is also suitable for outdoor use.; Designer: Ronan & Erwan Bouroullec; Manufacturer: Vitra; Model: Belleville armchair plastic; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; ProductDatasheet: https://www.vitra.com/en-https://www.vitra.com/en-un/_storage/asset/1009783/storage/master/download/FS_Bellville_Chair-EN_Preview-Single-Page.pdf; Type Name: Belleville armchair plastic; URL: https://www.vitra.com/en-un/living/product/details/belleville-armchair-plastic
Materials and Finishes(Type) - ChairSecondaryMaterial: 12 deep black; ChairTertiaryMaterial: Glide black
Other(Type) - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: CONV_Vitra_DmstcChrs_Belleville_Armchair; Features: Stackable, maximum 5.; Finish: Seat, base and frame: injection-moulded polyamide. Can be stacked up to 5 high.; Grade: n/a; Material: Polyamide; ModelNumber: n/a; ModelReference: 44029900; Name: DmstcChrs_Belleville_Armchair; ReplacementCost: n/a; Shape: Sculptured; Size: 550x490x830 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
